options:
  parameters:
    generate_options: qt_gui
    id: maxTest
    output_language: python
    title: detectortest
  states: {}

blocks:
- name: distance
  id: variable
  parameters:
    value: '5'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '868000000'
  states: {}
- name: indoor
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: ip
  id: variable
  parameters:
    value: '"0.0.0.0"'
  states: {}
- name: other_info
  id: variable
  parameters:
    value: '""'
  states: {}
- name: port
  id: variable
  parameters:
    value: '12345'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: save_directory
  id: variable
  parameters:
    value: '"LabOneByOne"'
  states: {}
- name: scenario
  id: variable
  parameters:
    value: '"NoLineOfSight550frames"'
  states: {}
- name: first_lora_detectSyncFS_0
  id: first_lora_detectSyncFS
  parameters:
    distance: distance
    indoor: 'True'
    ip_address: 0.0.0.0
    other_info: other_info
    port: '12345'
    sample_rate: samp_rate
    save_directory: save_directory
    scenario_name: scenario
  states: {}
- name: first_lora_lora_detector_0
  id: first_lora_lora_detector
  parameters:
    bw: '125000'
    method: '1'
    sampleRate: samp_rate
    sf: ' 7'
    threshold: ' 0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '868000000'
    gain0: '20'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [first_lora_lora_detector_0, '0', first_lora_detectSyncFS_0, '0']
- [first_lora_lora_detector_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', first_lora_lora_detector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
